Commit message: Offset solve example

File: src/urdf/planar_rr_arm.urdf (robot description, URDF)
Before this commit: robot planar_arm, 3 links, 2 joints
Links:
- added link tip
Joints:
- added joint joint_tip: type fixed, parent link2, child tip, origin xyz=1 0 0 rpy=0 0 0
